# Keil uVision project OSC_STM32F407.uvprojx, settings and files
target OSC_STM32F407 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: OSC_STM32F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__CC_ARM
  c include: ../Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Include;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ..\ENWIN;   ..\ENWIN\emWin_Config;   ..\ENWIN\emWin_Lib;   ..\HARDWARE;   ..\HARDWARE\LCD_MD050SD;   ..\SOFTWARE;   ..\SOFTWARE\GUI;   ..\Src;   C:\Keil_v5\ARM\ARMCC\include;   ..\ENWIN\inc;   ..\HARDWARE\LCD_ILI9325;   ..\Chips
  library: MicroLIB
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c main.h
    C:/Keil_v5/ARM/Pack/Keil/STM32F4xx_DFP/2.8.0/Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    C:/Keil_v5/ARM/Pack/Keil/STM32F4xx_DFP/2.8.0/Drivers/CMSIS/Include/: arm_math.h
    C:/Keil_v5/ARM/ARMCC/include/: stdint.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dac_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_ll_fsmc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group ESP_LCD
    ../HARDWARE/LCD_MD050SD/: LCD_MD050SD.c LCD_MD050SD.h LCD_MD050SD_Graph.c LCD_MD050SD_Graph.h LCD_MD050SD_Touch.c LCD_MD050SD_Touch.h
  group BSP_LCD
    ../HARDWARE/LCD_ILI9325/: LCD_ILI9325.c LCD_ILI9325.h LCD_ILI9325_Graph.c LCD_ILI9325_Graph.h LCD_ILI9325_Touch.c LCD_ILI9325_Touch.h
  group HARDWARE
    ../HARDWARE/: myADC.c myADC.h myKey.c myKey.h mySPI.c mySPI.h myUART.c myUART.h System.c System.h
  group SOFTWARE
    ../SOFTWARE/: Usual.c Usual.h DebugSupport.c DebugSupport.h FFT.c FFT.h FSM.c FSM.h OSC_Work.c OSC_Work.h TypeDefine.h
  group ENWIN
    ../ENWIN/emWin_Config/: GUI_X.c GUI_X_Touch_Analog.c GUIConf.c GUIConf.h GUIDRV_Template_BSP.c GUIDRV_Template_BSP.h GUIDRV_Template_ESP.c GUIDRV_Template_ESP.h LCDConf.h LCDConf_FlexColor_Template.c LCDConf_FlexColor_Template.h
    ../ENWIN/emWin_Lib/: STemWin528_CM4_Keil.lib
    ../ENWIN/inc/: BUTTON_Private.h
  group GUI
    ../SOFTWARE/GUI/: __UserGUI.c __UserGUI.h GUIControlStation.c GUIControlStation.h GUIDefine.h GUIDraw.c GUIDraw.h GUIGraph.c GUIGraph.h GUINumPad.c GUINumPad.h GUIUsual.c GUIUsual.h
  group Chips
    ../Chips/: ADS1110.c ADS1110.h ChipsDefine.h
software components: CMSIS:CORE 4.1.0
